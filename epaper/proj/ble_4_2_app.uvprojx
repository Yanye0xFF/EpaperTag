# Keil uVision project ble_4_2_app.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ble_4_2_app
  AfterMake: fromelf.exe  --bin -o ble_4_2_app.bin  Objects/ble_4_2_app.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --preinclude app_config.h --feedback=feedback.txt
  c include: ..\..\lib\ip\ble\hl\src\att\attc;..\..\lib\ip\ble\hl\src\att\attm;..\..\lib\ip\ble\hl\src\att\atts;..\..\lib\ip\ble\hl\src\att;..\..\lib\ip\ble\hl\src\gap;..\..\lib\ip\ble\hl\src\gap\gapc;..\..\lib\ip\ble\hl\src\gap\gapm;..\..\lib\ip\ble\hl\src\gatt;..\..\lib\ip\ble\hl\src\gatt\gattc;..\..\lib\ip\ble\hl\src\gatt\gattm;..\..\lib\ip\ble\hl\src\l2c\l2cc;..\..\lib\ip\ble\hl\src\l2c\l2cm;..\..\lib\ip\ble\hl\src\smp;..\..\lib\ip\ble\hl\src\smp\smpc;..\..\lib\ip\ble\hl\src\smp\smpm;..\..\lib\ip\ble\hl\src\rwble_hl;..\..\lib\ip\ble\ll\src\em;..\..\lib\ip\ble\ll\src\llc;..\..\lib\ip\ble\ll\src\lld;..\..\lib\ip\ble\ll\src\llm;..\..\lib\ip\ble\ll\src\rwble;..\..\lib\ip\ea\api;..\..\lib\ip\em\api;..\..\lib\ip\hci\api;..\..\lib\ip\hci\src;..\..\lib\modules\app\api;..\..\lib\modules\common\api;..\..\lib\modules\ahi\api;..\..\lib\modules\ecc_p256\api;..\..\lib\modules\h4tl\api;..\..\lib\modules\ke\api;..\..\lib\modules\nvds\api;..\..\lib\modules\button\api;..\..\lib\modules\sbc\api;..\..\lib\modules\rf\api;..\..\lib\modules\lowpow\api;..\..\lib\modules\dbg\api;..\..\lib\modules\rwip\api;..\..\lib\plf\refip\src\driver\apb2spi;..\..\lib\plf\refip\src\driver\eeprom;..\..\lib\plf\refip\src\driver\exti;..\..\lib\plf\refip\src\driver\flash;..\..\lib\plf\refip\src\driver\gpio;..\..\lib\plf\refip\src\driver\iic;..\..\lib\plf\refip\src\driver\intc;..\..\lib\plf\refip\src\driver\iomux;..\..\lib\plf\refip\src\driver\keyscan;..\..\lib\plf\refip\src\driver\pmu;..\..\lib\plf\refip\src\driver\reg;..\..\lib\plf\refip\src\driver\ssp;..\..\lib\plf\refip\src\driver\system;..\..\lib\plf\refip\src\driver\timer;..\..\lib\plf\refip\src\driver\uart;..\..\lib\plf\refip\src\driver\uart2;..\..\lib\plf\refip\src\driver\watchdog;..\..\lib\plf\refip\src\driver\audio;..\..\lib\plf\refip\src\build\ble-full\reg\fw;..\..\lib\plf\refip\src\arch;..\..\lib\plf\refip\src\arch\compiler\keil;..\..\lib\plf\refip\src\arch\ll\keil;..\..\lib\plf\refip\src\arch\boot\keil;..\..\lib\ip\ble\profiles;..\..\lib\ip\ble\profiles\dis\disc\api;..\..\lib\ip\ble\profiles\dis\diss\api;..\..\lib\ip\ble\profiles\hogp\hogpd\api;..\..\lib\ip\ble\profiles\hogp;..\..\lib\ip\ble\profiles\bas\bass\api;..\..\lib\ip\ble\profiles\ota\otas\api;..\..\lib\plf\refip\src\driver\i2s;..\..\lib\ip\ble\profiles\rtct\rtcts\api;..\..\lib\plf\refip\src\driver\led;..\..\lib\ip\ble\profiles\sps\sps_server\api;..\..\lib\modules\app\src\ssc_uart_test;..\..\lib\modules\app\src;..\..\lib\modules\app\src\user_profile\hogp;..\..\lib\modules\app\src\user_profile\hogp\hogpd_user\api;..\..\lib\modules\app\src\user_profile\ota\otas\api;..\..\lib\modules\decoder\inc;..\..\lib\modules\adpcm_ms\api;..\..\lib\modules\ke\src;..\..\lib\plf\refip\src\driver\adc;..\..\lib\plf\refip\src\driver\pwm;..\..\lib\plf\refip\src\driver\lvd;..\..\lib\plf\refip\src\driver\watchdog;..\..\lib\plf\refip\src\driver\rtc;..\code\driver;..\code\kvdb;..\code
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ble_4_2_app.sct
  link misc: --feedback=feedback.txt syscall.txt --entry=user_main --keep=_jump_table --datacompressor=off
  group app
    ../code/: app_config.h proj_main.c common.h epaper_svc.c epaper_svc.h gap_def.h request_handler.c request_handler.h utils.c utils.h shared_obj.c
  group app/driver
    ../code/driver/: driver_efuse.c driver_efuse.h softspi.c softspi.h ssd1680.c ssd1680.h systick.c
  group app/kvdb
    ../code/kvdb/: flash_tlv.c flash_tlv.h flash_tlv_cache.c flash_tlv_cache.h
  group lib_app
    ../../lib/modules/app/src/: app.c app_hid.c app_dis.c app_batt.c app_task.c app_sec.c app_otas.c app_rtct.c app_spss.c app_proj_event.c
  group lib_app_uart_ssc
    ../../lib/modules/app/src/ssc_uart_test/: dyc_uart_console_task.c dyc_uart_ssc.c
  group lib_boot
    ../../lib/plf/refip/src/arch/boot/keil/: boot_vectors.s
  group lib_system
    ../../lib/plf/refip/src/arch/boot/keil/: core_cm3_isr.c
    ../../lib/modules/app/src/: patch.c jump_table.c user_timer.c patch_ke_mem.c user_task.c user_msg_q.c user_profile.c user_sys.c
  group lib_profile
    ../../lib/ip/ble/profiles/rtct/rtcts/src/: rtcts.c rtcts_task.c
    ../../lib/ip/ble/profiles/sps/sps_server/src/: sps_server.c sps_server_task.c
    ../../lib/modules/app/src/: user_prf.c
    ../../lib/modules/app/src/user_profile/hogp/hogpd_user/src/: hogpd_task_user.c hogpd_user.c
    ../../lib/modules/app/src/user_profile/ota/otas/src/: otas_task_user.c otas_user.c
  group lib_driver
    ../../lib/plf/refip/src/driver/audio/: audio.c
    ../../lib/plf/refip/src/driver/i2s/: i2s.c
    ../../lib/plf/refip/src/driver/watchdog/: watchdog.c
    ../../lib/plf/refip/src/driver/adc/: adc.c
    ../../lib/plf/refip/src/driver/ssp/: ssp.c
    ../../lib/plf/refip/src/driver/lvd/: lvd.c
    ../../lib/plf/refip/src/driver/pwm/: pwm.c
    ../../lib/plf/refip/src/driver/gpio/: gpio_dbg_lib.c
    ../../lib/plf/refip/src/driver/rtc/: rtc.c
    ../../lib/plf/refip/src/driver/keyscan/: keyscan.c
  group lib_c_lib
    ../../lib/modules/app/src/: user_c_lib.c
  group lib_dec_sbc
    ../../lib/modules/sbc/src/: dec_sbc.c decoder_task.c
    ../../lib/modules/decoder/src/: alloc.c bitalloc.c bitalloc-sbc.c bitstream-decode.c decoder-oina.c decoder-private.c decoder-sbc.c dequant.c framing.c framing-sbc.c oi_codec_version.c synthesis-8-generated.c synthesis-dct8.c synthesis-sbc.c
    ../../lib/modules/adpcm_ms/src/: adpcm_ms.c
software components: CMSIS:CORE 5.0.0
